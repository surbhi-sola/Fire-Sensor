# Repository surbhi-sola/Fire-Sensor

File README.md:

# Fire-Sensor
Fire sensor made in KiCAD
Open the .csv file to see the components required.

## KiCad design First.kicad_pcb

Board: 2 copper layers, 40.6 x 55.9 mm, 11 parts (0 on the bottom side), 6 nets.

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1: 10uF; CP_Radial_D10.0mm_P3.50mm
D1: 1N4007; D_5W_P10.16mm_Horizontal
J1: DC; BarrelJack_Horizontal
M1, M2, M3: MountingHole_3.2mm_M3
Q1: 2N2219; TO-39-3
R1: 33K; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
RV1: 5K; Potentiometer_ACP_CA6-H2,5_Horizontal
TH1: 5K; PinHeader_1x02_P2.54mm_Horizontal

Connections:
unnamed: BZ1.1 (-), J1.1, TH1.1
unnamed: BZ1.2 (+), Q1.3 (C)
unnamed: C1.1, D1.2 (A), R1.2
unnamed: C1.2, J1.2, Q1.1 (E), RV1.2, RV1.3
unnamed: D1.1 (K), RV1.1, TH1.2
unnamed: Q1.2 (B), R1.1
